3845:	dsi@fde20000 {
3846-		rockchip,lane-rate = <0x1e0>;
3847-		compatible = "rockchip,rk3588-mipi-dsi2";
3848-		reg = <0x00 0xfde20000 0x00 0x10000>;
3849-		interrupts = <0x00 0xa7 0x04>;
3850-		clocks = <0x02 0x278 0x02 0x27a>;
3851-		clock-names = "pclk\0sys_clk";
3852-		resets = <0x02 0x354>;
3853-		reset-names = "apb";
3854-		power-domains = <0x4a 0x18>;
3855-		phys = <0x29>;
3856-		phy-names = "dcphy";
3857-		rockchip,grf = <0xb6>;
3858-		#address-cells = <0x01>;
3859-		#size-cells = <0x00>;
3860-		status = "okay";
3861-		phandle = <0x1f5>;
3862-
3863-		panel@0 {
3864-			phandle = <0x3d5>;
3865-			pinctrl-0 = <0x3d0>;
3866-			pinctrl-names = "default";
3867-			reset-gpios = <0xe0 0x11 0x00>;
3868-			vccio-supply = <0x237>;
3869-			vdd-supply = <0x3cf>;
3870-			backlight = <0x3ce>;
3871-			reg = <0x00>;
3872-			compatible = "uctronics,uctronics-lcd";
3873-			status = "okay";
3874-
3875-			ports {
3876-				#size-cells = <0x00>;
3877-				#address-cells = <0x01>;
3878-
3879-				port@0 {
3880-					reg = <0x00>;
3881-
3882-					endpoint {
3883-						phandle = <0x3d2>;
3884-						remote-endpoint = <0x3d1>;
3885-					};
3886-				};
3887-			};
3888-		};
3889-
3890-		ports {
3891-			#address-cells = <0x01>;
3892-			#size-cells = <0x00>;
3893-
3894-			port@1 {
3895-				reg = <0x01>;
3896-
3897-				endpoint {
3898-					phandle = <0x3d1>;
3899-					remote-endpoint = <0x3d2>;
3900-				};
3901-			};
3902-
3903-			port@0 {
3904-				reg = <0x00>;
3905-				#address-cells = <0x01>;
	dsi0-backlight {
		phandle = <0x3ce>;
		pinctrl-0 = <0x3cd>;
		pinctrl-names = "default";
		enable-gpios = <0xe0 0x1a 0x00>;
		default-brightness-level = <0xc8>;
		brightness-levels = <0xff 0xfe 0xfd 0xfc 0xfb 0xfa 0xf9 0xf8 0xf7 0xf6 0xf5 0xf4 0xf3 0xf2 0xf1 0xf0 0xef 0xee 0xed 0xec 0xeb 0xea 0xe9 0xe8 0xe7 0xe6 0xe5 0xe4 0xe3 0xe2 0xe1 0xe0 0xdf 0xde 0xdd 0xdc 0xdb 0xda 0xd9 0xd8 0xd7 0xd6 0xd5 0xd4 0xd3 0xd2 0xd1 0xd0 0xcf 0xce 0xcd 0xcc 0xcb 0xca 0xc9 0xc8 0xc7 0xc6 0xc5 0xc4 0xc3 0xc2 0xc1 0xc0 0xbf 0xbe 0xbd 0xbc 0xbb 0xba 0xb9 0xb8 0xb7 0xb6 0xb5 0xb4 0xb3 0xb2 0xb1 0xb0 0xaf 0xae 0xad 0xac 0xab 0xaa 0xa9 0xa8 0xa7 0xa6 0xa5 0xa4 0xa3 0xa2 0xa1 0xa0 0x9f 0x9e 0x9d 0x9c 0x9b 0x9a 0x99 0x98 0x97 0x96 0x95 0x94 0x93 0x92 0x91 0x90 0x8f 0x8e 0x8d 0x8c 0x8b 0x8a 0x89 0x88 0x87 0x86 0x85 0x84 0x83 0x82 0x81 0x80 0x7f 0x7e 0x7d 0x7c 0x7b 0x7a 0x79 0x78 0x77 0x76 0x75 0x74 0x73 0x72 0x71 0x70 0x6f 0x6e 0x6d 0x6c 0x6b 0x6a 0x69 0x68 0x67 0x66 0x65 0x64 0x63 0x62 0x61 0x60 0x5f 0x5e 0x5d 0x5c 0x5b 0x5a 0x59 0x58 0x57 0x56 0x55 0x54 0x53 0x52 0x51 0x50 0x4f 0x4e 0x4d 0x4c 0x4b 0x4a 0x49 0x48 0x47 0x46 0x45 0x44 0x43 0x42 0x41 0x40 0x3f 0x3e 0x3d 0x3c 0x3b 0x3a 0x39 0x38 0x37 0x36 0x35 0x34 0x33 0x32 0x31 0x30 0x2f 0x2e 0x2d 0x2c 0x2b 0x2a 0x29 0x28 0x27 0x26 0x26 0x25 0x25 0x24 0x24 0x23 0x23 0x22 0x22 0x21 0x21 0x20 0x20 0x1f 0x1f 0x1e 0x1e 0x1d 0x1d 0x1c 0x1c 0x1b 0x1b 0x1a 0x1a 0x19 0x19 0x18 0x18 0x17 0x17 0x16 0x16 0x15 0x15 0x14 0x14 0x00>;
		pwms = <0x24f 0x00 0x61a8 0x00>;
		compatible = "pwm-backlight";
		status = "okay";
	};

	vcc-lcd-mipi0 {
		phandle = <0x3cf>;
		regulator-boot-on;
		enable-active-high;
		gpio = <0x164 0x04 0x00>;
		regulator-name = "vcc_lcd_mipi0";
		compatible = "regulator-fixed";
		status = "okay";

		regulator-state-mem {
			regulator-off-in-suspend;
		};
	};

	vcc-tp {
		phandle = <0x3d4>;
		regulator-always-on;
		regulator-boot-on;
		enable-active-low;
	vcc-lcd-mipi0 {
		phandle = <0x3cf>;
		regulator-boot-on;
		enable-active-high;
		gpio = <0x164 0x04 0x00>;
		regulator-name = "vcc_lcd_mipi0";
		compatible = "regulator-fixed";
		status = "okay";

		regulator-state-mem {
			regulator-off-in-suspend;
		};
	};

	vcc-tp {
		phandle = <0x3d4>;
	vcc-tp {
		phandle = <0x3d4>;
		regulator-always-on;
		regulator-boot-on;
		enable-active-low;
		gpio = <0xce 0x1d 0x01>;
		regulator-name = "vcc_tp";
		compatible = "regulator-fixed";
		status = "okay";
	};

	aliases {
		csi2dcphy0 = "/csi2-dcphy0";
		csi2dcphy1 = "/csi2-dcphy1";
		csi2dphy0 = "/csi2-dphy0";
		csi2dphy1 = "/csi2-dphy1";
		dsi0-lcd {

			dsi0-backlight-en {
				phandle = <0x3cd>;
				rockchip,pins = <0x03 0x1a 0x00 0x15c>;
			};

			dsi0-lcd-rst-gpio {
				phandle = <0x3d0>;
				rockchip,pins = <0x03 0x11 0x00 0x15c>;
			};
		};

		gpio@fd8a0000 {
			compatible = "rockchip,gpio-bank";
			reg = <0x00 0xfd8a0000 0x00 0x100>;
